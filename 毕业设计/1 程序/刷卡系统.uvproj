# Keil uVision project 刷卡系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 刷卡系统
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c MFRC522.H RC522.C 12864.c
